# Keil uVision project Project.uvprojx, settings and files
target 神舟III号 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SZ_STM32F103ZE_DEMO +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\;.\..\Libraries\CMSIS\CM3\CoreSupport;.\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\Utilities\STM32_EVAL;.\..\Utilities\STM32_EVAL\Common;.\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\LIB;..\SYSTEM\delay;..\HARDWARE\IMU;..\HARDWARE\myiic;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\sys;..\HARDWARE\IMU;..\madgwick_algorithm_c\MahonyAHRS;..\HARDWARE\src;..\HARDWARE\inc;..\HARDWARE\UARTs;..\kalman
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c
  group StdPeriph_Driver
    ./../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK_start_code
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group IMU
    ../HARDWARE/UARTs/: IOI2C.c wit_c_sdk.c UART1.c
  group system
    ../SYSTEM/delay/: delay.c
  group UARTs
    ../HARDWARE/UARTs/: UART2.c
